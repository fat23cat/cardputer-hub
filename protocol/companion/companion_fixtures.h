#pragma once
#include <cstddef>
#include <cstdint>
namespace cardputer_hub::companion_fixtures {
struct Fixture { const char* name; const std::uint8_t* bytes; std::size_t size; };
inline constexpr std::uint8_t hello[] = { 0xC7, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x1F, 0x80, 0xD4, 0x5B, 0xFF, 0x96, 0x39, 0xC8, 0x12, 0x32, 0x30, 0x32, 0x36, 0x2D, 0x30, 0x39, 0x2D, 0x32, 0x39, 0x20, 0x61, 0x62, 0x63, 0x31, 0x32, 0x33, 0x34 };
inline constexpr std::uint8_t hello_ack[] = { 0xC7, 0x02, 0x2A, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x1F, 0x80, 0xD4, 0x5B, 0xFF, 0x96, 0x39, 0xC8, 0x12, 0x32, 0x30, 0x32, 0x36, 0x2D, 0x30, 0x39, 0x2D, 0x32, 0x39, 0x20, 0x61, 0x62, 0x63, 0x31, 0x32, 0x33, 0x34 };
inline constexpr std::uint8_t hello_ack_mismatch[] = { 0xC7, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1B, 0xFF, 0xEE, 0xDD, 0xCC, 0xBB, 0xAA, 0x99, 0x88, 0x12, 0x32, 0x30, 0x32, 0x36, 0x2D, 0x30, 0x39, 0x2D, 0x32, 0x39, 0x20, 0x61, 0x62, 0x63, 0x31, 0x32, 0x33, 0x34 };
inline constexpr std::uint8_t ping_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x01, 0x01, 0x00, 0x04, 0x01, 0x02, 0x03, 0x04 };
inline constexpr std::uint8_t ping_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x01, 0x01, 0x00, 0x04, 0x01, 0x02, 0x03, 0x04 };
inline constexpr std::uint8_t app_active_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x03, 0x03, 0x00, 0x00 };
inline constexpr std::uint8_t app_active_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x0B, 0x64, 0x65, 0x76, 0x2E, 0x7A, 0x65, 0x64, 0x2E, 0x5A, 0x65, 0x64 };
inline constexpr std::uint8_t app_activate_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x04, 0x04, 0x00, 0x15, 0x14, 0x6F, 0x72, 0x67, 0x2E, 0x74, 0x65, 0x6C, 0x65, 0x67, 0x72, 0x61, 0x6D, 0x2E, 0x64, 0x65, 0x73, 0x6B, 0x74, 0x6F, 0x70 };
inline constexpr std::uint8_t app_activate_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x04, 0x04, 0x00, 0x00 };
inline constexpr std::uint8_t app_active_changed_event[] = { 0xC7, 0x05, 0x2A, 0x00, 0x00, 0x05, 0x00, 0x0C, 0x0B, 0x64, 0x65, 0x76, 0x2E, 0x7A, 0x65, 0x64, 0x2E, 0x5A, 0x65, 0x64 };
inline constexpr std::uint8_t system_metrics_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x05, 0x06, 0x00, 0x00 };
inline constexpr std::uint8_t system_metrics_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x05, 0x06, 0x00, 0x1A, 0xFF, 0x01, 0x22, 0xEC, 0x2C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x3F, 0x52, 0x02, 0x9A, 0x31, 0x00, 0x00, 0x33, 0x07, 0x00, 0x00, 0x02, 0x66, 0x00 };
inline constexpr std::uint8_t ai_usage_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x07, 0x07, 0x00, 0x00 };
inline constexpr std::uint8_t ai_usage_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x07, 0x07, 0x00, 0x22, 0x02, 0x01, 0x09, 0x00, 0x00, 0x00, 0x03, 0x04, 0x01, 0x01, 0x01, 0x01, 0x08, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x5C, 0x00, 0xA5, 0x18, 0x6A, 0x10, 0x0E, 0x00, 0x00, 0x00 };
inline constexpr std::uint8_t system_details_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01 };
inline constexpr std::uint8_t system_details_response_cpu[] = { 0xC7, 0x04, 0x2A, 0x00, 0x08, 0x08, 0x00, 0x1D, 0x01, 0x0F, 0x00, 0x3D, 0x12, 0x1B, 0x02, 0x26, 0x05, 0x58, 0x63, 0x6F, 0x64, 0x65, 0x15, 0x0D, 0x47, 0x6F, 0x6F, 0x67, 0x6C, 0x65, 0x20, 0x43, 0x68, 0x72, 0x6F, 0x6D, 0x65 };
inline constexpr std::uint8_t system_details_response_power[] = { 0xC7, 0x04, 0x2A, 0x00, 0x08, 0x08, 0x00, 0x16, 0x02, 0x1F, 0x00, 0x8E, 0x00, 0x60, 0x5B, 0xD6, 0x00, 0x0C, 0x0B, 0x4D, 0x61, 0x67, 0x69, 0x63, 0x20, 0x4D, 0x6F, 0x75, 0x73, 0x65 };
inline constexpr std::uint8_t system_details_response_network[] = { 0xC7, 0x04, 0x2A, 0x00, 0x08, 0x08, 0x00, 0x0A, 0x03, 0x0F, 0x00, 0x12, 0x00, 0x03, 0x00, 0xCA, 0x62, 0x03 };
inline constexpr std::uint8_t system_details_response_memory[] = { 0xC7, 0x04, 0x2A, 0x00, 0x08, 0x08, 0x00, 0x1F, 0x04, 0x0F, 0x00, 0x66, 0x38, 0x00, 0x00, 0x9A, 0x0F, 0x00, 0x00, 0x9A, 0x0D, 0x00, 0x00, 0xCD, 0x04, 0x00, 0x00, 0xD4, 0x00, 0xE2, 0x03, 0x00, 0x50, 0x05, 0x00, 0x00, 0xE8, 0x00, 0x00 };
inline constexpr std::uint8_t inventory_list_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x15, 0x09, 0x00, 0x02, 0x00, 0x00 };
inline constexpr std::uint8_t inventory_list_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x15, 0x09, 0x00, 0x3F, 0x02, 0x00, 0x02, 0x00, 0x02, 0x0F, 0x1E, 0x2D, 0x3C, 0x4B, 0x5A, 0x69, 0x78, 0x87, 0x96, 0xA5, 0xB4, 0xC3, 0xD2, 0xE1, 0xF0, 0x01, 0x03, 0x00, 0x00, 0x00, 0x0E, 0xD0, 0xA7, 0xD0, 0xB5, 0xD0, 0xBC, 0xD0, 0xBE, 0xD0, 0xB4, 0xD0, 0xB0, 0xD0, 0xBD, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00 };
inline constexpr std::uint8_t inventory_get_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x16, 0x0A, 0x00, 0x12, 0x0F, 0x1E, 0x2D, 0x3C, 0x4B, 0x5A, 0x69, 0x78, 0x87, 0x96, 0xA5, 0xB4, 0xC3, 0xD2, 0xE1, 0xF0, 0x00, 0x00 };
inline constexpr std::uint8_t inventory_get_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x16, 0x0A, 0x00, 0x8E, 0x03, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x7B, 0x22, 0x73, 0x63, 0x68, 0x65, 0x6D, 0x61, 0x22, 0x3A, 0x32, 0x2C, 0x22, 0x69, 0x64, 0x22, 0x3A, 0x22, 0x30, 0x66, 0x31, 0x65, 0x32, 0x64, 0x33, 0x63, 0x34, 0x62, 0x35, 0x61, 0x36, 0x39, 0x37, 0x38, 0x38, 0x37, 0x39, 0x36, 0x61, 0x35, 0x62, 0x34, 0x63, 0x33, 0x64, 0x32, 0x65, 0x31, 0x66, 0x30, 0x22, 0x2C, 0x22, 0x72, 0x65, 0x76, 0x69, 0x73, 0x69, 0x6F, 0x6E, 0x22, 0x3A, 0x33, 0x2C, 0x22, 0x6E, 0x61, 0x6D, 0x65, 0x22, 0x3A, 0x22, 0xD0, 0xA7, 0xD0, 0xB5, 0xD0, 0xBC, 0xD0, 0xBE, 0xD0, 0xB4, 0xD0, 0xB0, 0xD0, 0xBD, 0x22, 0x2C, 0x22, 0x64, 0x65, 0x73, 0x63, 0x72, 0x69, 0x70, 0x74, 0x69, 0x6F, 0x6E, 0x22, 0x3A, 0x22, 0xD0, 0x97, 0xD0, 0xB0, 0xD1, 0x80, 0xD1, 0x8F, 0xD0, 0xB4, 0xD0, 0xBA, 0xD0, 0xB0, 0x2C, 0x20, 0xD1, 0x81, 0xD0, 0xB2, 0xD0, 0xB8, 0xD1, 0x82, 0xD0, 0xB5, 0xD1, 0x80, 0x22, 0x7D };
inline constexpr std::uint8_t inventory_get_not_available[] = { 0xC7, 0x04, 0x2A, 0x00, 0x16, 0x0A, 0x01, 0x00 };
inline constexpr std::uint8_t inventory_put_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x17, 0x0B, 0x00, 0xC4, 0x0F, 0x1E, 0x2D, 0x3C, 0x4B, 0x5A, 0x69, 0x78, 0x87, 0x96, 0xA5, 0xB4, 0xC3, 0xD2, 0xE1, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xAC, 0x00, 0x00, 0x00, 0x7B, 0x22, 0x73, 0x63, 0x68, 0x65, 0x6D, 0x61, 0x22, 0x3A, 0x32, 0x2C, 0x22, 0x69, 0x64, 0x22, 0x3A, 0x22, 0x30, 0x66, 0x31, 0x65, 0x32, 0x64, 0x33, 0x63, 0x34, 0x62, 0x35, 0x61, 0x36, 0x39, 0x37, 0x38, 0x38, 0x37, 0x39, 0x36, 0x61, 0x35, 0x62, 0x34, 0x63, 0x33, 0x64, 0x32, 0x65, 0x31, 0x66, 0x30, 0x22, 0x2C, 0x22, 0x72, 0x65, 0x76, 0x69, 0x73, 0x69, 0x6F, 0x6E, 0x22, 0x3A, 0x33, 0x2C, 0x22, 0x6E, 0x61, 0x6D, 0x65, 0x22, 0x3A, 0x22, 0xD0, 0xA1, 0xD0, 0xB8, 0xD0, 0xBD, 0xD0, 0xB8, 0xD0, 0xB9, 0x20, 0xD1, 0x87, 0xD0, 0xB5, 0xD0, 0xBC, 0xD0, 0xBE, 0xD0, 0xB4, 0xD0, 0xB0, 0xD0, 0xBD, 0x22, 0x2C, 0x22, 0x64, 0x65, 0x73, 0x63, 0x72, 0x69, 0x70, 0x74, 0x69, 0x6F, 0x6E, 0x22, 0x3A, 0x22, 0xD0, 0xA8, 0xD1, 0x82, 0xD0, 0xB0, 0xD0, 0xBD, 0xD1, 0x8B, 0x2C, 0x20, 0xD1, 0x88, 0xD0, 0xBE, 0xD1, 0x80, 0xD1, 0x82, 0xD1, 0x8B, 0x5C, 0x6E, 0xD0, 0x9D, 0xD0, 0xBE, 0xD1, 0x81, 0xD0, 0xBA, 0xD0, 0xB8, 0x5C, 0x6E, 0xD0, 0x9B, 0xD1, 0x8B, 0xD0, 0xB6, 0xD0, 0xB8, 0x20, 0xC2, 0xAB, 0x41, 0x74, 0x6F, 0x6D, 0x69, 0x63, 0xC2, 0xBB, 0x22, 0x7D };
inline constexpr std::uint8_t inventory_put_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x17, 0x0B, 0x00, 0x06, 0xAC, 0x00, 0x04, 0x00, 0x00, 0x00 };
inline constexpr std::uint8_t inventory_put_conflict[] = { 0xC7, 0x04, 0x2A, 0x00, 0x17, 0x0B, 0x05, 0x04, 0x05, 0x00, 0x00, 0x00 };
inline constexpr std::uint8_t inventory_delete_request[] = { 0xC7, 0x03, 0x2A, 0x00, 0x18, 0x0C, 0x00, 0x14, 0x0F, 0x1E, 0x2D, 0x3C, 0x4B, 0x5A, 0x69, 0x78, 0x87, 0x96, 0xA5, 0xB4, 0xC3, 0xD2, 0xE1, 0xF0, 0x04, 0x00, 0x00, 0x00 };
inline constexpr std::uint8_t inventory_delete_response[] = { 0xC7, 0x04, 0x2A, 0x00, 0x18, 0x0C, 0x00, 0x00 };
inline constexpr std::uint8_t legacy_hello[] = { 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0x04, 0x06, 0x05, 0x04, 0x03 };
inline constexpr std::uint8_t malformed_length[] = { 0xC7, 0x03, 0x2A, 0x00, 0x01, 0x01, 0x00, 0x0A, 0x01, 0x02 };
inline constexpr std::uint8_t unknown_marker[] = { 0x42, 0x03, 0x2A, 0x00, 0x01, 0x01, 0x00, 0x04, 0x01, 0x02, 0x03, 0x04 };
inline constexpr std::uint8_t wrong_session[] = { 0xC7, 0x04, 0x63, 0x00, 0x01, 0x01, 0x00, 0x04, 0x01, 0x02, 0x03, 0x04 };
inline constexpr std::uint8_t unknown_operation[] = { 0xC7, 0x03, 0x2A, 0x00, 0x01, 0x7F, 0x00, 0x00 };
inline constexpr Fixture all[] = {
    {"hello.bin", hello, sizeof(hello)},
    {"hello-ack.bin", hello_ack, sizeof(hello_ack)},
    {"hello-ack-mismatch.bin", hello_ack_mismatch, sizeof(hello_ack_mismatch)},
    {"ping-request.bin", ping_request, sizeof(ping_request)},
    {"ping-response.bin", ping_response, sizeof(ping_response)},
    {"app-active-request.bin", app_active_request, sizeof(app_active_request)},
    {"app-active-response.bin", app_active_response, sizeof(app_active_response)},
    {"app-activate-request.bin", app_activate_request, sizeof(app_activate_request)},
    {"app-activate-response.bin", app_activate_response, sizeof(app_activate_response)},
    {"app-active-changed-event.bin", app_active_changed_event, sizeof(app_active_changed_event)},
    {"system-metrics-request.bin", system_metrics_request, sizeof(system_metrics_request)},
    {"system-metrics-response.bin", system_metrics_response, sizeof(system_metrics_response)},
    {"ai-usage-request.bin", ai_usage_request, sizeof(ai_usage_request)},
    {"ai-usage-response.bin", ai_usage_response, sizeof(ai_usage_response)},
    {"system-details-request.bin", system_details_request, sizeof(system_details_request)},
    {"system-details-response-cpu.bin", system_details_response_cpu, sizeof(system_details_response_cpu)},
    {"system-details-response-power.bin", system_details_response_power, sizeof(system_details_response_power)},
    {"system-details-response-network.bin", system_details_response_network, sizeof(system_details_response_network)},
    {"system-details-response-memory.bin", system_details_response_memory, sizeof(system_details_response_memory)},
    {"inventory-list-request.bin", inventory_list_request, sizeof(inventory_list_request)},
    {"inventory-list-response.bin", inventory_list_response, sizeof(inventory_list_response)},
    {"inventory-get-request.bin", inventory_get_request, sizeof(inventory_get_request)},
    {"inventory-get-response.bin", inventory_get_response, sizeof(inventory_get_response)},
    {"inventory-get-not-available.bin", inventory_get_not_available, sizeof(inventory_get_not_available)},
    {"inventory-put-request.bin", inventory_put_request, sizeof(inventory_put_request)},
    {"inventory-put-response.bin", inventory_put_response, sizeof(inventory_put_response)},
    {"inventory-put-conflict.bin", inventory_put_conflict, sizeof(inventory_put_conflict)},
    {"inventory-delete-request.bin", inventory_delete_request, sizeof(inventory_delete_request)},
    {"inventory-delete-response.bin", inventory_delete_response, sizeof(inventory_delete_response)},
    {"legacy-hello.bin", legacy_hello, sizeof(legacy_hello)},
    {"malformed-length.bin", malformed_length, sizeof(malformed_length)},
    {"unknown-marker.bin", unknown_marker, sizeof(unknown_marker)},
    {"wrong-session.bin", wrong_session, sizeof(wrong_session)},
    {"unknown-operation.bin", unknown_operation, sizeof(unknown_operation)},
};
inline const Fixture* find(const char* name) {
    for (const auto& fixture : all) {
        const char* left = fixture.name;
        const char* right = name;
        while (*left != '\0' && *left == *right) { ++left; ++right; }
        if (*left == '\0' && *right == '\0') return &fixture;
    }
    return nullptr;
}
} // namespace cardputer_hub::companion_fixtures
